v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -0 30 -0 50 {lab=PLUS}
N 0 -50 -0 -30 {lab=MINUS}
C {DP.sym} 0 -30 0 0 {name=D1 model=DP m=1}
C {devices/ipin.sym} 0 50 3 0 {name=p1 lab=PLUS}
C {devices/opin.sym} 0 -50 3 0 {name=p2 lab=MINUS}
